Commit message: Update model.urdf

File: nevbot/src/nevbot_description/urdf/model.urdf (robot description, URDF)
Before this commit: robot nevbot, 6 links, 5 joints
Links:
- link hokuyo: geometry collision box size=0.1 0.1 0.1; visual mesh filename=package://nevbot_description/meshes/hokuyo.dae
